# IAR project sensor-actuator-node.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P232F256GM48 SiliconLaboratories EFR32MG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: APP_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; EFR32MG1P; EFR32MG1P232F256GM48; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_BRD4151A; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; MBEDTLS_CONFIG_FILE="stack/ip/tls/mbedtls/config.h"; MFGLIB; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\..\stack; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\rf4ce\include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\util; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\ecode; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emlib\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib\dmd; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\common\drivers; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\common\bsp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\EFR32MG1_BRD4151A\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; EFR32MG1P; EFR32MG1P232F256GM48; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; BOARD_BRD4151A; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; MBEDTLS_CONFIG_FILE="stack/ip/tls/mbedtls/config.h"; MFGLIB; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\..\stack; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\rf4ce\include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\protocol\thread_2.0\app\thread\..\util; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\ecode; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\emlib\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib\dmd; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\common\drivers; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\common\bsp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\hardware\kit\EFR32MG1_BRD4151A\config
  OBJCOPY.OOCOutputFile: sensor-actuator-node.s37
  prebuild: sensor-actuator-node-prebuild.bat $PROJ_DIR$
  postbuild: sensor-actuator-node-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: sensor-actuator-node.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\stacks\thread\v2.0.0.0\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/dhcp-library-cortexm3-iar-efr32mg1p-efr32/: dhcp-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/hal-library-cortexm3-iar-efr32mg1p-efr32/: hal-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/heartbeat-node-type-library-cortexm3-iar-efr32mg1p-efr32/: heartbeat-node-type-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/mbedtls-library-cortexm3-iar-efr32mg1p-efr32/: mbedtls-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/mfglib-library-cortexm3-iar-efr32mg1p-efr32/: mfglib-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-efr32/: sim-eeprom1-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/build/thread-stack-cortexm3-iar-efr32mg1p-efr32/: thread-stack.a
  group emdrv
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/spidrv/src/: spidrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/uartdrv/src/: uartdrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/../../Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group adc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: adc.c
  group address-configuration-debug
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/address-configuration-debug/: address-configuration-debug.c
  group antenna-stub
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/generic/: antenna-stub.c
  group button
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: button.c
  group button-press
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/button-press/: button-press.c
  group buzzer
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: buzzer.c
  group cli
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/cli/: cli.c
  group coap-cli
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/coap-cli/: coap-cli.c
  group coap-dispatch
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/coap-dispatch/: coap-dispatch.c
  group command-interpreter2
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/util/serial/: command-interpreter2-error.c command-interpreter2-util.c command-interpreter2.c
  group debug-print
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/debug-print/: debug-print.c
  group dhcp-client
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/dhcp-client/: dhcp-client.c
  group diagnostic
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: diagnostic.c
  group glib
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c glib_line.c glib_rectangle.c glib_string.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: graphics.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group hal-library
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c cstartup-common.c faults-v7m.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token-def.c token.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c
  group heartbeat-node-type
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/heartbeat-node-type/: heartbeat-node-type.c
  group icmp-cli
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/icmp-cli/: icmp-cli.c
  group icmp-debug
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/icmp-debug/: icmp-debug.c
  group idle-sleep
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/idle-sleep/: idle-sleep.c
  group led
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: led.c
  group main
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/main/: main.c
  group network-management-cli
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/network-management-cli/: network-management-cli.c
  group scan-debug
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/scan-debug/: scan-debug.c
  group serial
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/plugin/serial/: ember-printf.c serial.c
  group sim-eeprom1
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/generic/: sim-eeprom.c
  group slaac-client
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/slaac-client/: slaac-client.c
  group tftp-bootload-target
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/util/bootload/tftp-bootloader/server/: tftp-bootloader-server.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/util/bootload/tftp-bootloader/: tftp-bootloader-15-4.c tftp-bootloader.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/util/bootload/tftp/server/: tftp-server.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/util/bootload/tftp/: tftp-15-4.c tftp.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/tftp-bootload-target/: tftp-bootload.c
  group thread-stack
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/stack/config/: ember-ip-configuration.c
  group udp-cli
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/udp-cli/: udp-cli.c
  group version-debug
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/protocol/thread_2.0/app/thread/plugin/version-debug/: version-debug.c
  group Generated
    ./: thread-bookkeeping.c thread-coap-dispatch.c thread-events.c thread-callback-stubs.c thread-callbacks.c thread-cli.c
  group Additional
    ./: sensor-actuator-node-implementation.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/common/: bootloader-interface.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/stacks/thread/v2.0.0.0/platform/base/hal/micro/cortexm3/efm32/: bootloader-interface-app.c
